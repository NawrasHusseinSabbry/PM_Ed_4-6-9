#include <Arduino.h>
#include <avr/io.h>
#include <stdlib.h>
#include <avr/pgmspace.h>

#define add Ed25519_add
#define sub Ed25519_sub
#define modulo Ed25519_modulo

typedef struct { unsigned char Ed[32]; } field_element;

extern "C"
{
  void sub(field_element *r, const field_element *x, const field_element *y);
  void add(field_element *r, const field_element *x, const field_element *y);
  void modulo(field_element *r, unsigned char *C);
  char Ed_num_sub_prime(unsigned char* r, const unsigned char* a);
  char Ed25519_square(unsigned char* r, const unsigned char* a);
  char Ed_mul(unsigned char* r, const unsigned char* a, const unsigned char* b);
  unsigned char scalar_sub_halforder(unsigned char* r, const unsigned char* a);
  unsigned char scalar_sub_order(unsigned char* r, const unsigned char* a);
  char Ed255_subp_bigint(unsigned char* r, const unsigned char* a);
}

void in_range(field_element *r);
void Ed25519_scalar_sub_order(field_element *r);
void flip_if(field_element *r, const field_element *x, unsigned char b);
void mul(field_element *r, const field_element *x, const field_element *y);
void square(field_element *r, const field_element *x);
void M_Inverse_Z(field_element *r, const field_element *x);

static const field_element d = {{0xA3, 0x78, 0x59, 0x13, 0xCA, 0x4D, 0xEB, 0x75, 0xAB, 0xD8, 0x41, 0x41, 0x4D, 0x0A, 0x70, 0x00, 0x98, 0xE8, 0x79, 0x77, 0x79, 0x40, 0xC7, 0x8C, 0x73, 0xFE, 0x6F, 0x2B, 0xEE, 0x6C, 0x03, 0x52}};
static const field_element a = {{0xEC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F}};
static const field_element PRECOMPUTED_POINTS[17][3] PROGMEM = 
{
  {{0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00},
  {0x01, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00},
  {0x01, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00,	0x00, 0x00, 0x00, 0x00}},

  {{0x1A, 0xD5, 0x25, 0x8F,	0x60, 0x2D, 0x56, 0xC9,	0xB2, 0xA7, 0x25, 0x95,	0x60, 0xC7, 0x2C, 0x69, 0x5C, 0xDC, 0xD6, 0xFD, 0x31, 0xE2, 0xA4, 0xC0, 0xFE, 0x53, 0x6E, 0xCD, 0xD3, 0x36, 0x69, 0x21},
  {0x58, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66},
  {0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}},

  {{0x57, 0x0A, 0x30, 0x18, 0x4C, 0x86, 0xBA, 0x7A, 0x5B, 0x62, 0x71, 0xFA, 0xDD, 0xC1, 0x6E, 0x88, 0x09, 0xF9, 0xB0, 0xB7, 0x87, 0x4B, 0x22, 0xEA, 0x4A, 0x25, 0x7C, 0x9A, 0xDB, 0x1D, 0x24, 0x31},
  {0xD7, 0x7F, 0x2D, 0x5E, 0xD9, 0x2C, 0x4B, 0x92, 0x1C, 0x32, 0xBE, 0x2B, 0x66, 0xAA, 0x47, 0x0A, 0xF6, 0x51, 0xC9, 0x3A, 0xFC, 0x82, 0xB7, 0x69, 0xDB, 0x33, 0xC9, 0x6C, 0x4C, 0x98, 0x24, 0x33},
  {0x6B, 0xDE, 0x78, 0x02, 0x3D, 0xA9, 0x74, 0x63, 0xD1, 0x99, 0x92, 0x33, 0x00, 0x61, 0xD3, 0xEB, 0x92, 0x62, 0x42, 0x3B, 0xFA, 0xD1, 0x98, 0x40, 0x57, 0x7C, 0x57, 0x6B, 0x79, 0xC5, 0x86, 0x69}},

  {{0x85, 0x99, 0xEB, 0xC9, 0xB1, 0x53, 0x37, 0xC2, 0x4E, 0xAF, 0x4B, 0x52, 0x8F, 0x6B, 0xA0, 0x90, 0xF3, 0xB1, 0xC6, 0x35, 0x53, 0xA9, 0x4A, 0xCE, 0x13, 0x7E, 0x6B, 0x77, 0xBC, 0x2F, 0x8E, 0x6B},
  {0x64, 0x76, 0xEC, 0x03, 0x88, 0xF6, 0x75, 0xDF, 0xEE, 0x52, 0xF7, 0xA9, 0x12, 0xF1, 0x9D, 0x0B, 0x17, 0x02, 0x16, 0x67, 0xE7, 0x8C, 0x58, 0x65, 0x78, 0xFF, 0xBF, 0x0C, 0x7C, 0x31, 0x9A, 0x16},
  {0xE9, 0xD8, 0x02, 0x1D, 0x63, 0x4B, 0x5F, 0x8B, 0x01, 0x91, 0x3F, 0x05, 0x9B, 0x69, 0xBD, 0x7C, 0x85, 0x14, 0x7B, 0xC4, 0xB0, 0x65, 0x99, 0xE7, 0x65, 0x55, 0x8F, 0xA6, 0x98, 0xBE, 0xE9, 0x61}},

  {{0x95, 0x05, 0x02, 0xE9, 0x8E, 0xA7, 0xAD, 0x05, 0xDB, 0x30, 0x01, 0x98, 0x1B, 0xE1, 0x3E, 0xD8, 0xBB, 0x7F, 0xF7, 0x52, 0x34, 0xBF, 0x3F, 0xE9, 0x95, 0x9F, 0xD1, 0x92, 0x90, 0xE2, 0xD6, 0x7A},
  {0xDC, 0x08, 0xB3, 0x80, 0x79, 0x52, 0x3C, 0x4C, 0x0F, 0x29, 0x4C, 0xC4, 0xD6, 0x3D, 0x64, 0xBE, 0x4D, 0x48, 0x9F, 0xEA, 0x85, 0x11, 0xD8, 0x39, 0x35, 0xAD, 0x90, 0x00, 0xAE, 0x83, 0xC9, 0x12},
  {0xB8, 0xEB, 0x15, 0x44, 0x11, 0x3C, 0x49, 0xE2, 0xC2, 0xDC, 0x77, 0x4C, 0xD6, 0x9A, 0x50, 0xDC, 0xFF, 0xB8, 0xD8, 0xA0, 0xD8, 0xD0, 0x48, 0x15, 0xB1, 0xDD, 0x0A, 0x32, 0x96, 0x6B, 0x6E, 0x78}},

  {{0x1D, 0xDE, 0xB6, 0x92, 0xCA, 0x24, 0xF5, 0x02, 0x25, 0x98, 0xF1, 0x0F, 0x16, 0x40, 0x12, 0xEA, 0xEC, 0xF3, 0x1B, 0xA1, 0x79, 0x8E, 0xC2, 0x39, 0x59, 0x7E, 0x68, 0xD6, 0xF9, 0x63, 0xE1, 0x3D},
  {0x22, 0x15, 0x90, 0x17, 0x59, 0x93, 0xCF, 0xA8, 0xC5, 0xF2, 0x8E, 0xFB, 0x53, 0xC5, 0xA3, 0x24, 0x79, 0xEE, 0xD6, 0x84, 0x80, 0x7D, 0x0F, 0x8F, 0x39, 0xFA, 0x6F, 0xE4, 0x03, 0x4C, 0x62, 0x3E},
  {0x3E, 0x00, 0x27, 0x17, 0xA5, 0x99, 0xD7, 0x73, 0x85, 0xDB, 0x24, 0x84, 0xD4, 0xE0, 0x2D, 0x3F, 0x0F, 0x14, 0x45, 0x44, 0xC8, 0xFC, 0xB2, 0x85, 0x61, 0xE0, 0xAC, 0x0C, 0xD5, 0xF8, 0x99, 0x7A}},

  {{0xF1, 0xE2, 0x5B, 0x3B, 0xB9, 0x62, 0xB3, 0xDC, 0xD9, 0xF4, 0x72, 0x5F, 0xD2, 0xF5, 0x70, 0x7F, 0x39, 0xA6, 0x5C, 0xB6, 0x85, 0xC7, 0x73, 0x84, 0xCB, 0x22, 0x18, 0xF1, 0x08, 0x49, 0xDD, 0x19},
  {0xCA, 0x04, 0x83, 0x31, 0xB9, 0x7F, 0x14, 0x21, 0xBC, 0xF4, 0x55, 0x93, 0x9E, 0x78, 0x8B, 0x04, 0xCF, 0xF0, 0x20, 0x9E, 0x70, 0xBC, 0xB7, 0xEA, 0xE2, 0xAF, 0x6D, 0x4A, 0x2B, 0x34, 0x5F, 0x4D},
  {0x81, 0x1D, 0x45, 0x5B, 0x8D, 0xCF, 0xEB, 0x8E, 0x2F, 0x61, 0x55, 0xFE, 0x7B, 0x64, 0x05, 0x34, 0xB0, 0x83, 0x08, 0xEB, 0xB1, 0x5C, 0xD5, 0x52, 0x0B, 0x21, 0xED, 0xED, 0x7C, 0x6B, 0xC0, 0x2C}},

  {{0xBA, 0xDB, 0xD3, 0xBE, 0x60, 0x7E, 0xB1, 0x89, 0xE0, 0x81, 0x48, 0x66, 0xB7, 0x51, 0x3F, 0xAC, 0x9B, 0x18, 0x86, 0x1D, 0x6D, 0x7E, 0x2E, 0x54, 0xCC, 0x11, 0x65, 0x22, 0xFA, 0x4B, 0xDB, 0x6D},
  {0x7B, 0xC4, 0x14, 0x49, 0xE2, 0x14, 0x87, 0xBB, 0xE0, 0x1C, 0x1B, 0x8D, 0xAA, 0xD6, 0x9C, 0x36, 0x28, 0x5C, 0xAC, 0x24, 0x8B, 0x6B, 0x51, 0xB0, 0x3C, 0x6C, 0xC1, 0x7B, 0x8C, 0xC6, 0x95, 0x0C},
  {0x7A, 0xDC, 0xC5, 0x25, 0xB9, 0x87, 0x89, 0xE7, 0x01, 0x96, 0x45, 0x96, 0x3D, 0x32, 0x28, 0xAE, 0x0D, 0x37, 0x80, 0x44, 0xE3, 0xC4, 0x0C, 0x65, 0x37, 0xF0, 0x62, 0xE8, 0x82, 0x5B, 0x34, 0x72}},

  {{0xDA, 0xB5, 0x9D, 0xD9, 0x91, 0x10, 0x80, 0xA0, 0x58, 0xA6, 0xEC, 0xEA, 0x67, 0x15, 0xD5, 0x63, 0x33, 0xF0, 0xFB, 0xC0, 0xE6, 0x64, 0xE2, 0xB8, 0x88, 0x50, 0x8F, 0xAE, 0xDA, 0x89, 0x13, 0x61},
  {0x2F, 0x58, 0x70, 0xEF, 0x27, 0x1F, 0x15, 0xD1, 0x14, 0xE5, 0xE9, 0xFB, 0xA0, 0xAE, 0xE6, 0x05, 0x31, 0xA8, 0x4E, 0xA4, 0x59, 0x41, 0x0F, 0x17, 0xCF, 0xA9, 0x36, 0xF4, 0x72, 0x3B, 0x59, 0x00},
  {0xEF, 0x7D, 0x91, 0x5C, 0xB3, 0x43, 0xF7, 0xB8, 0xBF, 0xBC, 0x6E, 0x5A, 0x87, 0x73, 0xF3, 0xF6, 0x72, 0x75, 0x80, 0x67, 0xB1, 0x8E, 0x70, 0xB0, 0xE5, 0xB8, 0x45, 0x30, 0xC2, 0xE5, 0x21, 0x55}},

  {{0x49, 0x9D, 0xA0, 0x31, 0xF7, 0x0D, 0x46, 0x40, 0xF5, 0xC4, 0x30, 0xC4, 0x07, 0x16, 0xDE, 0x0F, 0xE7, 0x91, 0x2D, 0x96, 0xCB, 0x4E, 0x6D, 0x00, 0x67, 0x70, 0xCC, 0x80, 0x69, 0x08, 0x37, 0x64},
  {0x72, 0x13, 0x73, 0xF3, 0x92, 0x59, 0x16, 0x52, 0x72, 0x27, 0xA1, 0x36, 0x5C, 0x47, 0x12, 0x15, 0x08, 0x9D, 0xF2, 0x49, 0xF3, 0x97, 0xC9, 0x43, 0x25, 0xD1, 0xA5, 0x11, 0xA8, 0xB5, 0xE7, 0x43},
  {0xD9, 0xF1, 0xE2, 0x1D, 0x79, 0x0D, 0x60, 0xE1, 0xAA, 0xAC, 0x30, 0x3C, 0x01, 0x91, 0xFA, 0xC8, 0x31, 0xBE, 0xDA, 0xE3, 0x03, 0x11, 0x16, 0xBF, 0x18, 0x1A, 0x5A, 0x82, 0x4B, 0x2E, 0x25, 0x30}},

  {{0x1D, 0x7C, 0x07, 0x8D, 0x98, 0x5B, 0xD8, 0xC7, 0xFE, 0x69, 0x1C, 0x7E, 0xF7, 0x20, 0xED, 0xAD, 0x0E, 0x9D, 0xA7, 0x6E, 0x42, 0x21, 0xBE, 0xC0, 0xC4, 0x41, 0x5E, 0x72, 0xAE, 0x1A, 0x59, 0x72},
  {0x11, 0xFA, 0xA7, 0xB5, 0x7F, 0x3D, 0x1E, 0xB8, 0x59, 0xE2, 0x2E, 0x09, 0x7F, 0x77, 0xC1, 0xC6, 0x9D, 0x57, 0x25, 0xC5, 0x9F, 0xD0, 0xBC, 0x59, 0xA0, 0xC3, 0x9B, 0x50, 0xEB, 0x69, 0x73, 0x02},
  {0x98, 0x1E, 0x1B, 0xF5, 0x8C, 0x5E, 0xD9, 0xCE, 0x7D, 0x1D, 0x6D, 0x8C, 0xA5, 0xA9, 0x9E, 0x7B, 0x82, 0x83, 0xB2, 0xCF, 0x14, 0x44, 0x9B, 0x81, 0x9D, 0x33, 0x3A, 0x3A, 0xF2, 0xF6, 0x4F, 0x01}},

  {{0x75, 0x71, 0xD7, 0xF5, 0xBC, 0x48, 0x93, 0x70, 0x47, 0x1D, 0xA7, 0x02, 0x1F, 0x34, 0x51, 0x68, 0x46, 0x87, 0xEC, 0xF6, 0xF9, 0x95, 0x59, 0x75, 0x98, 0x4E, 0xBF, 0x57, 0x1D, 0x9A, 0xA0, 0x54},
  {0x61, 0xA9, 0x3F, 0xF6, 0x9F, 0xEE, 0x05, 0x2A, 0xA5, 0xFC, 0x8A, 0x43, 0xD7, 0x4B, 0x29, 0x64, 0x56, 0x7B, 0x20, 0x86, 0x10, 0xBF, 0x71, 0xCE, 0x05, 0xD4, 0x9B, 0x72, 0x59, 0xAA, 0x18, 0x31},
  {0xE2, 0xEA, 0xEF, 0xFB, 0xF6, 0x7B, 0x24, 0xD0, 0x53, 0x63, 0x5C, 0xAC, 0x36, 0x28, 0x97, 0x13, 0x77, 0xF8, 0xDB, 0x25, 0x03, 0x43, 0xAA, 0x58, 0x66, 0x98, 0x2D, 0x83, 0x64, 0xC8, 0xD2, 0x09}},

  {{0xC7, 0x40, 0x06, 0x6A, 0xD7, 0x47, 0x1E, 0xAF, 0x9A, 0xF5, 0xDD, 0x67, 0xA0, 0x9A, 0x97, 0x6B, 0x03, 0x07, 0xA1, 0x15, 0x9B, 0x91, 0xD5, 0x13, 0x29, 0x5B, 0x43, 0x96, 0xC7, 0x63, 0x3D, 0x56},
  {0x91, 0x32, 0x6F, 0xAB, 0xED, 0xFE, 0xCB, 0x35, 0x25, 0x9A, 0x98, 0xE1, 0x55, 0xCD, 0xD0, 0xCF, 0x1B, 0x9C, 0x6E, 0x5F, 0x54, 0x97, 0xEE, 0xEA, 0x7A, 0x50, 0x01, 0xDD, 0x90, 0x4F, 0x5A, 0x7E},
  {0x25, 0x83, 0x96, 0x1C, 0x91, 0xB1, 0x46, 0xE1, 0xB0, 0x13, 0xF1, 0xE5, 0xDA, 0xB5, 0x91, 0xE4, 0xB6, 0x60, 0x88, 0xD1, 0x1C, 0x8E, 0xDC, 0x18, 0x28, 0x73, 0x1D, 0xED, 0xBB, 0xC4, 0xE7, 0x6E}},

  {{0xDE, 0x09, 0x6D, 0x35, 0xE4, 0xB1, 0x43, 0xD9, 0x3F, 0xD2, 0x10, 0x1E, 0xA0, 0x15, 0x96, 0xAC, 0xC7, 0x8A, 0x55, 0x50, 0xE6, 0xDC, 0xFA, 0x18, 0x3C, 0x15, 0xF7, 0xE5, 0x6C, 0x67, 0x34, 0x0B},
  {0xF1, 0x8C, 0xE1, 0x9F, 0x72, 0xFB, 0xC4, 0x4C, 0x7E, 0x75, 0x11, 0xBD, 0x49, 0x0A, 0x68, 0xE4, 0xC2, 0xA5, 0xC1, 0x31, 0x43, 0xEA, 0x9F, 0xBB, 0x56, 0xA2, 0x25, 0xAF, 0x8D, 0x0E, 0xDA, 0x04},
  {0x83, 0x61, 0x6B, 0x22, 0x35, 0x3B, 0x17, 0xB8, 0xA0, 0x85, 0x12, 0x88, 0x24, 0x4C, 0xB4, 0xA3, 0xFA, 0xA1, 0x7C, 0xF0, 0x9A, 0x5B, 0x03, 0x96, 0x72, 0x37, 0xE5, 0x5C, 0xEE, 0x2B, 0x85, 0x7A}},

  {{0x8B, 0x43, 0x8B, 0x72, 0xD4, 0xE4, 0x8A, 0x15, 0x77, 0x84, 0x02, 0x11, 0x50, 0xCB, 0x86, 0x7F, 0x60, 0x22, 0xFF, 0xBA, 0xCF, 0x77, 0x84, 0x0D, 0xC0, 0xA0, 0xAB, 0xE2, 0x92, 0xC4, 0x38, 0x62},
  {0x4B, 0xF2, 0xE5, 0x35, 0xA6, 0x3D, 0xEF, 0x5C, 0x96, 0xC1, 0xF3, 0x79, 0x0C, 0x54, 0x75, 0x41, 0x56, 0xC1, 0x1C, 0xB4, 0xC7, 0x03, 0x21, 0xE9, 0x93, 0xA8, 0x1D, 0xBF, 0x0C, 0x7C, 0xE9, 0x19},
  {0x13, 0xD5, 0x94, 0xAE, 0xB8, 0x9D, 0x51, 0xC6, 0x6C, 0xF6, 0x0A, 0x4F, 0xD0, 0xFD, 0xAB, 0x44, 0x78, 0x4B, 0x92, 0xBE, 0x59, 0x0D, 0xE7, 0x4D, 0x39, 0xB7, 0xE1, 0xDF, 0x2C, 0xB2, 0xB2, 0x4D}},

  {{0x06, 0xF4, 0x34, 0x02, 0x40, 0x99, 0x40, 0xB0, 0x34, 0x02, 0xFE, 0x3E, 0xA4, 0x33, 0xFC, 0xA1, 0x59, 0xCF, 0xAF, 0xD3, 0x30, 0x10, 0x26, 0x92, 0x15, 0xCC, 0xDA, 0x00, 0x83, 0x08, 0x4E, 0x2F},
  {0x43, 0xFF, 0x67, 0x41, 0x8E, 0x2F, 0xD7, 0x0E, 0x51, 0xC6, 0x53, 0xEE, 0xB0, 0xA5, 0x41, 0x12, 0xEE, 0x31, 0xB0, 0x37, 0xB1, 0xB5, 0xD7, 0xE8, 0x99, 0xA6, 0x1B, 0x1C, 0x18, 0xC4, 0x39, 0x51},
  {0x8F, 0xF1, 0x68, 0x0F, 0x22, 0x2E, 0xAE, 0xCA, 0x88, 0x6F, 0x20, 0xD8, 0x55, 0xE3, 0x9E, 0xF3, 0x35, 0xB2, 0x5C, 0xAB, 0x8B, 0x88, 0x80, 0xE4, 0x97, 0xE7, 0x38, 0x02, 0xBD, 0x5F, 0x0D, 0x58}},

  {{0x42, 0xF6, 0x3E, 0x16, 0xAD, 0x60, 0x71, 0xE2, 0x67, 0x3E, 0xC4, 0xB0, 0x05, 0xFD, 0x89, 0x6D, 0x31, 0x42, 0x53, 0x7B, 0x4F, 0x9A, 0xCC, 0xE8, 0xA0, 0x0C, 0xA1, 0x9C, 0x96, 0x73, 0xD2, 0x4D},
  {0x50, 0x2F, 0x9D, 0x2B, 0xF2, 0xE6, 0x97, 0x8D, 0x6D, 0xFD, 0xFB, 0x4B, 0xA1, 0x0B, 0x6D, 0x22, 0x5F, 0xCE, 0xC8, 0x7A, 0x15, 0x60, 0xAB, 0xE7, 0x3E, 0x92, 0xE9, 0x1F, 0x3A, 0xF7, 0xE0, 0x6F},
  {0x82, 0xBA, 0x90, 0xB6, 0x06, 0xC6, 0x60, 0x98, 0x7A, 0x8D, 0xF4, 0xD9, 0x07, 0x6E, 0xF2, 0xF5, 0xD7, 0x38, 0x0E, 0x50, 0x5C, 0x5C, 0x4F, 0x42, 0x3E, 0x37, 0x07, 0x88, 0x35, 0x05, 0xF8, 0x20}},
};

volatile unsigned long overflow_count = 0;
ISR(TIMER1_OVF_vect) {overflow_count++;}

int main()
{
  Serial.begin(500000);
  Serial.println();

  //scalar (saved using little endian in 32 byte hex array) = 3618502788666131106986593281521497120428558180689953803000975469142727125494 = 0x80000000000000000000000000000000a6f7cfbf0a86b3b727e1f776e7ae9f6
  unsigned char scalar[32] = {0xF6,	0xE9,	0x7A,	0x6E,	0x77,	0x1F,	0x7E,	0x72,	0x3B,	0x6B,	0xA8,	0xF0,	0xFB,	0x7C,	0x6F,	0x0A,	0x00,	0x00,	0x00,	0x00,	0x00,	0x00,	0x00,	0x00,	0x00,	0x00,	0x00,	0x00,	0x00,	0x00,	0x00,	0x08};

  field_element Gx = {{0x1A, 0xD5, 0x25, 0x8F, 0x60, 0x2D, 0x56, 0xC9, 0xB2, 0xA7, 0x25, 0x95, 0x60, 0xC7, 0x2C, 0x69, 0x5C, 0xDC, 0xD6, 0xFD, 0x31, 0xE2, 0xA4, 0xC0, 0xFE, 0x53, 0x6E, 0xCD, 0xD3, 0x36, 0x69, 0x21}};
  field_element Gy = {{0x58, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66}};
  field_element Gz = {{0x01}};
  field_element temp_scalar;

  field_element xr, yr, zr;

  cli();
  TCCR1A = 0;
  TCCR1B = bit(CS10);
  TCNT1 = 0;
  overflow_count = 0;

  TIMSK1 |= (1 << TOIE1);
  sei();

  scalar[0] &= 248;
  scalar[31] &= 127;
  scalar[31] |= 64;

  for (int i = 0; i < 32; i++){temp_scalar.Ed[i] = scalar[i];}
  for (int i = 0; i < 7; i++){Ed25519_scalar_sub_order(&temp_scalar);}
  for (int i = 0; i < 32; i++){scalar[i] = temp_scalar.Ed[i];}

  windowed_scalar_mul(&Gx, &Gy, &Gz, scalar, PRECOMPUTED_POINTS);

  cli();
  unsigned long final_cycles = TCNT1;
  sei();

  unsigned long total_cycles = (overflow_count * 65536UL) + final_cycles;

  Serial.print("Number of cycles = ");
  Serial.println(total_cycles);

  Serial.print("Time requirement = ");
  Serial.print((float)total_cycles / 16);
  Serial.println(" Microseconds");

  Serial.print("Time requirement = ");
  Serial.print((float)total_cycles / 16000);
  Serial.println(" Millisecond");

  Serial.print("Time requirement = ");
  Serial.print((float)total_cycles / 16000000);
  Serial.println(" second");
  
  Serial.print("Affine x-coordinate: ");
  for (int i = 0; i < 32; i++)
  {
    Serial.print(Gx.Ed[i], HEX);
  }
  Serial.println();
}

void windowed_scalar_mul(field_element *xr, field_element *yr, field_element *zr, unsigned char scalar[32], const field_element precomputed[16][3])
{
  field_element temp_result;
  unsigned char borrow;

  cli();
  borrow = scalar_sub_halforder(temp_result.Ed, scalar);
  sei();

  if (borrow == 0)
  {
    for (int i = 0; i < 32; i++){ scalar[i] = temp_result.Ed[i];}

    windowed_scalar_mul(xr, yr, zr, scalar, precomputed);

    cli();
    Ed255_subp_bigint(xr->Ed, xr->Ed);
    Ed255_subp_bigint(yr->Ed, yr->Ed);
    sei();
    return;
  }
  unsigned char window_value = scalar[31] & 0x0F;
  memcpy_P(xr->Ed, precomputed[window_value][0].Ed, 32);
  memcpy_P(yr->Ed, precomputed[window_value][1].Ed, 32);
  memcpy_P(zr->Ed, precomputed[window_value][2].Ed, 32);

  for (int i = 30; i >= 0; i--)
  {
    for (int j = 3; j >= 0; j--)
    {
      double_point(xr, yr, zr);
    }
    field_element temp_x, temp_y, temp_z;
    window_value = (scalar[i] >> 4);

    memcpy_P(temp_x.Ed, precomputed[window_value][0].Ed, 32);
    memcpy_P(temp_y.Ed, precomputed[window_value][1].Ed, 32);
    memcpy_P(temp_z.Ed, precomputed[window_value][2].Ed, 32);

    add_points(xr, yr, zr, &temp_x, &temp_y, &temp_z);

    for (int j = 3; j >= 0; j--)
    {
      double_point(xr, yr, zr);
    }

    window_value = (scalar[i] & 0x0F);
    
    memcpy_P(temp_x.Ed, precomputed[window_value][0].Ed, 32);
    memcpy_P(temp_y.Ed, precomputed[window_value][1].Ed, 32);
    memcpy_P(temp_z.Ed, precomputed[window_value ][2].Ed, 32);

    add_points(xr, yr, zr, &temp_x, &temp_y, &temp_z);
  }

  M_Inverse_Z(zr, zr);
  mul(xr, xr, zr);
  in_range(xr);
}

void double_point(field_element *xr, field_element *yr, field_element *zr)
{
  field_element B, C, D, E, F, H, J;
  field_element temp1;
  add(&temp1, xr, yr);
  square(&B, &temp1);
  square(&C, xr);
  square(&D, yr);
  mul(&E, &a, &C);
  add(&F, &E, &D);
  square(&H, zr);
  add(&temp1, &H, &H);
  sub(&J, &F, &temp1);
  sub(&temp1, &B, &C);
  sub(&temp1, &temp1, &D);
  mul(xr, &temp1, &J);
  sub(&temp1, &E, &D);
  mul(yr, &F, &temp1);
  mul(zr, &F, &J);
}

void add_points(field_element *xr, field_element *yr, field_element *zr, const field_element *px, const field_element *py, const field_element *pz)
{
  field_element A, B, C, D, E, F, G, temp1, temp2;
  mul(&A, zr, pz);
  square(&B, &A);
  mul(&C, xr, px);
  mul(&D, yr, py);
  mul(&E, &C, &D);
  mul(&E, &E, &d);
  sub(&F, &B, &E);
  add(&G, &B, &E);
  add(&temp1, xr, yr);  
  add(&temp2, px, py);
  mul(&temp1, &temp1, &temp2);
  sub(&temp1, &temp1, &C);
  sub(&temp1, &temp1, &D);
  mul(&temp1, &F, &temp1);
  mul(xr, &A, &temp1);
  mul(&temp1, &a, &C);
  sub(&temp1, &D, &temp1);
  mul(&temp1, &G, &temp1);
  mul(yr, &A, &temp1);
  mul(zr, &F, &G);
}

void M_Inverse_Z(field_element *r, const field_element *x)
{
  field_element z2;
  field_element z11;
  field_element z2_10_0;
  field_element z2_50_0;
  field_element z2_100_0;
  field_element t0;
  field_element t1;
  unsigned char i;

  square(&z2,x);
  square(&t1,&z2);
  square(&t0,&t1);
  mul(&z2_10_0,&t0,x);
  mul(&z11,&z2_10_0,&z2);
  square(&t0,&z11);
  mul(&z2_10_0,&t0,&z2_10_0);
  square(&t0,&z2_10_0);
  square(&t1,&t0);
  square(&t0,&t1);
  square(&t1,&t0);
  square(&t0,&t1);
  mul(&z2_10_0,&t0,&z2_10_0);
  square(&t0,&z2_10_0);
  square(&t1,&t0);
  for (i = 2;i < 10;i += 2){ square(&t0,&t1); square(&t1,&t0); }
  mul(&z2_50_0,&t1,&z2_10_0);
  square(&t0,&z2_50_0);
  square(&t1,&t0);
  for (i = 2;i < 20;i += 2) { square(&t0,&t1); square(&t1,&t0); }
  mul(&t0,&t1,&z2_50_0);
  square(&t1,&t0);
  square(&t0,&t1);
  for (i = 2;i < 10;i += 2) { square(&t1,&t0); square(&t0,&t1); }
  mul(&z2_50_0,&t0,&z2_10_0);
  square(&t0,&z2_50_0);
  square(&t1,&t0);
  for (i = 2;i < 50;i += 2) { square(&t0,&t1); square(&t1,&t0); }
  mul(&z2_100_0,&t1,&z2_50_0);
  square(&t1,&z2_100_0);
  square(&t0,&t1);
  for (i = 2;i < 100;i += 2) { square(&t1,&t0); square(&t0,&t1); }
  mul(&t1,&t0,&z2_100_0);
  square(&t0,&t1);
  square(&t1,&t0);
  for (i = 2;i < 50;i += 2) { square(&t0,&t1); square(&t1,&t0); }
  mul(&t0,&t1,&z2_50_0);
  square(&t1,&t0);
  square(&t0,&t1);
  square(&t1,&t0);
  square(&t0,&t1);
  square(&t1,&t0);
  mul(r,&t1,&z11);
}

void in_range(field_element *r)
{
  unsigned char bwr;
  field_element temp_result;
  bwr = Ed_num_sub_prime(temp_result.Ed, r->Ed);
  flip_if(r,&temp_result,1-bwr);
}

void flip_if(field_element *r, const field_element *x, unsigned char b)
{
  unsigned char i;
  unsigned long mask = b;
  mask = -mask;
  for(i=0;i<32;i++)
  {
    r->Ed[i] ^= mask & (x->Ed[i] ^ r->Ed[i]);
  }
}

void mul(field_element *r, const field_element *x, const field_element *y)
{
  unsigned char t[64];
  cli();
  Ed_mul(t,x->Ed,y->Ed);
  sei();
  modulo(r,t);
}

void square(field_element *r, const field_element *x)
{
  unsigned char t[64];
  cli();
  Ed25519_square(t,x->Ed);
  sei();
  modulo(r,t);
}

void Ed25519_scalar_sub_order(field_element *r)
{
  unsigned char bwr;
  field_element tempResult;
  cli();
  bwr = scalar_sub_order(tempResult.Ed, r->Ed);
  sei();
  flip_if(r,&tempResult,1-bwr);
}